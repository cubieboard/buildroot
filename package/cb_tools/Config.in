## package/cb_tools/Config.in
```kconfig
config BR2_PACKAGE_CB_TOOLS
	bool "cb_tools"
	depends on BR2_PACKAGE_LIBSYSFS
	help
	  tools for cubieboard
```
